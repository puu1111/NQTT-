# Keil uVision project FAT32文件系统(保存ADC采集值).uvproj, settings and files
target FAT32文件系统(保存ADC采集值) (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FAT32文件系统(保存ADC采集值) +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\inc;..\FATFS;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\MALLOC;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: delay.c usart1.c sd.c adc.c
    ../HARDWARE/: queue.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_adc.c
  group DOC
    ../: readme.txt
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group MALLOC
    ../MALLOC/: mymalloc.c
